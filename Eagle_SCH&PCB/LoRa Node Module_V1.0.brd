# Repository Elecrow-RD/LoRa_Node_Expansion_Board_nRFLR1110_Integrates_nRF52840

## EAGLE design Eagle_SCH&PCB/LoRa Node Module_V1.0.brd

Parts:
ANT1: ANT2.4G_BLE; 2.4G_BLE
ANT2, ANT3, ANT4: C5137195; MYSELF_IPEX1
C1, C3: 10uF/0603; C0603
C2, C6, C9, C12, C18, C19, C33: 100nF; C0402
C4, C10: 47pF; C0402
C5: 2.4nH_NC; DISCRETE-NEW_C0402
C7, C8: 22uF; 0603
C11: 3.9nH; DISCRETE-NEW_C0402
C13, C17, C55: NC; DISCRETE-NEW_C0402
C14, C16: NC; C0402
C15, C61: 12pF; DISCRETE-NEW_C0402
C30: 22UF; 0603
C31, C32: 1UF; C0603
C53: 0R; DISCRETE-NEW_C0402
C60: 4.3nH; DISCRETE-NEW_C0402
D2, D3: SS24; SMA
FB1, FB2: 120R/2A/BLM18PG121SN1D; L0603
IC1: CN3163-SOP8-PAD; SOP8-PAD
J1, J2, J4, J6, J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J5, J11: PH2.0WT-2PIN
J8: 2.0MM-4P
J9, J12: CONN_07NO_SILK; 1X07_NO_SILK
K1, K2: BUTTON; 157SW
L2, L3, L12: 0R; XADOW-GPS-V2_DISCRETE-NEW_L0402
L4: 4.7uH/1.6A; A9G_DISCRETE_L0805
L5: 0R; L0402
L7: 27nH; L0402
L14: 6.8nH; XADOW-GPS-V2_DISCRETE-NEW_L0402
LED1: RED; DISCRETE_LED-0603
LED2: BLUE; DISCRETE_LED-0603
LED3: GREEN; LED0603
P1: TEST_PAD; TEST_PAD-1.5MM
Q1: BSS138LT1; SOT-323
Q2, Q3: AO3401; PMOS_SOT23
Q4: CJ3407A; SOT-323
R1: 45.3K; R0402
R2, R16: 0R; DISCRETE-NEW_R0402
R3, R22: 4.7K; 0402
R4, R6: 4.7K; R0402
R5, R7, R11, R12: 0R; R0402
R8, R9: 0R_NC; R0402
R10: 1k; R0402
R13, R27: 100k; R0402
R14, R36: 100K; R0402
R15: 1.2K 1%; R0402
R17: 45.3K; 0402
R18, R23: 22R; 0402
R19, R20, R21: 10K; 0402
R24, R25: 5.1K; 0402
U1: RY3420; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
U3: nRFLRXXXX_MODULE_A_SMD80nRFLRXXXX_MO_SMT80; LR11XX_MO_A_SMD80
U4: W25Q64JVXGIQ; XSON-EP(4×4)
Y2: 32.768K; NORDIC_NRF_XTAL_3215_N

Connections:
3V3: C8.2, C9.1, FB1.2, FB2.2, J1.3, J2.3, J4.3, J6.3, J7.3, J8.P$1, J9.7, J10.3, J12.7, L4.2, Q4.2 (S), R3.2, R4.2, R6.2, R13.2, R17.2, R20.2, R21.2, R22.2, U4.8 (VCC)
+SOLAR: J11.P$1, Q2.3 (D)
+VBAT: C32.2, IC1.5 (BAT), IC1.8 (FB), J5.P$1, Q3.3 (D)
+VBUS: D2.2 (+), D3.2 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), Q2.1 (G), Q3.1 (G), R14.1, R36.1, U3.37 (VBUS)
+VIN: C30.2, C31.2, D3.1 (-), IC1.4 (VIN), Q2.2 (S), R1.2
+VSYS: C6.1, C7.2, D2.1 (-), Q3.2 (S), U1.1 (EN), U1.4 (VIN)
CHRG: IC1.7 (CHRG), R7.2, R9.2
D+: J3.A6 (DP1), J3.B6 (DP2), R23.2
D-: J3.A7 (DN1), J3.B7 (DN2), R18.2
DN: R18.1, U3.40 (DN)
DP: R23.1, U3.41 (DP)
GND: ANT2.P$2, ANT2.P$3, ANT3.P$2, ANT3.P$3, ANT4.P$2, ANT4.P$3, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.1, C17.2, C18.2, C19.2, C30.1, C31.1, C32.1, C33.1, C55.2, C60.2, C61.2, IC1.1 (TEMP), IC1.3 (GND), IC1.PAD (EP), J1.4, J1.SS1, J1.SS2, J2.4, J2.SS1, J2.SS2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$1, J3.P$2, J3.P$3, J3.P$4, J4.4, J4.SS1, J4.SS2, J5.P$2, J5.P$3, J5.P$4, J6.4, J6.SS1, J6.SS2, J7.4, J7.SS1, J7.SS2, J8.P$2, J9.1, J9.2, J10.4, J10.SS1, J10.SS2, J11.P$2, J11.P$3, J11.P$4, J12.1, K1.1, K2.1, LED1.-, Q1.2 (S), R5.2, R14.2, R15.1, R19.1, R24.1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
LNA_CTL_P0.31: R10.2, U3.10 (P0.31)
LR_DIO7: R12.2, U3.24 (LR_DIO7)
LR_DIO8: P1.P$1, U3.23 (LR_32K_OUT)
LR_DIO9: R11.2, U3.11 (LR_DIO9)
unnamed: LED2.+, R22.1
unnamed: L12.1, U3.54 (ANT_BLE)
unnamed: C5.1, L2.2, L3.1
unnamed: ANT2.P$1, C13.1, L3.2
unnamed: L2.1, U3.65 (ANT_WIFI)
unnamed: J3.B5 (CC2), R24.2
unnamed: LED3.-, R7.1, R8.1
unnamed: C55.1, R2.1, U3.67 (ANT_GNSS)
unnamed: R16.1, U3.72 (ANT_LORA)
unnamed: LED1.+, R3.1
unnamed: LED3.+, R1.1
unnamed: J3.A5 (CC1), R25.1
unnamed: L4.1, U1.3 (SW)
unnamed: C14.2, L5.1, R16.2
unnamed: IC1.2 (ISET), R15.2
unnamed: ANT4.P$1, C16.2, L5.2
unnamed: Q1.3 (D), Q4.1 (G), R13.1
unnamed: Q1.1 (G), R10.1, R27.2
unnamed: IC1.6 (DONE), R5.1
unnamed: R17.1, R19.2, U1.5 (FB)
unnamed: C33.2, L7.1, Q4.3 (D)
unnamed: C17.1, C53.2, R2.2
unnamed: C60.1, L12.2, L14.1
unnamed: ANT1.P$1, C11.1, L14.2
P0.00/XL1: C15.1, U3.29 (P0.00), Y2.2
P0.01/XL2: C61.1, U3.30 (P0.01), Y2.1
P0.02: J9.3, U3.12 (P0.02)
P0.03: J9.4, U3.13 (P0.03)
P0.04/AIN2: J7.1, U3.31 (P0.04)
P0.05/AIN3: J7.2, U3.17 (P0.05)
P0.06: R8.2, U3.32 (P0.06)
P0.07: J9.6, U3.19 (P0.07)
P0.08/D2: J4.2, U3.33 (P0.08)
P0.11: R12.1, U3.25 (P0.11)
P0.12/D2: J4.1, U3.35 (P0.12)
P0.13/SDA_0: J6.2, R20.1, U3.39 (P0.13)
P0.14/SCL_0: J6.1, R21.1, U3.38 (P0.14)
P0.15: J12.6, U3.42 (P0.15)
P0.16: R9.1, U3.26 (P0.16)
P0.17: J12.5, U3.43 (P0.17)
P0.18/NRESET: C18.1, K1.2, R4.1, U3.36 (P0.18)
P0.20: J12.4, U3.45 (P0.20)
P0.21: J12.3, U3.49 (P0.21)
P0.22/UART_RXD: J10.1, U3.46 (P0.22)
P0.23/QSPI_IO3: U3.59 (P0.23), U4.7 (/HOLD/RESET(IO3))
P0.24/UART_TXD: J10.2, U3.47 (P0.24)
P0.25: J12.2, U3.52 (P0.25)
P0.26/D1: J2.1, U3.18 (P0.26)
P0.27/D1: J2.2, U3.16 (P0.27)
P0.28/AIN4: J1.1, U3.14 (P0.28)
P0.29/AIN5: J1.2, U3.9 (P0.29)
P0.30: J9.5, U3.15 (P0.30)
P1.00/USER_KEY: C19.1, K2.2, R6.1, U3.48 (P1.00)
P1.01/QSPI_IO2: U3.60 (P1.01), U4.3 (/WP(IO2))
P1.02/QSPI_IO0: U3.58 (P1.02), U4.5 (DI(IO0))
P1.03/QSPI_IO1: U3.61 (P1.03), U4.2 (DO(IO1))
P1.04/QSPI_SCK: U3.57 (P1.04), U4.6 (CLK)
P1.05/QSPI_CS: U3.62 (P1.05), U4.1 (/CS)
P1.08: R11.1, U3.20 (P1.08)
P1.09/LED: LED2.-, U3.34 (P1.09)
RF_GPS: ANT3.P$1, C53.1, L7.2
SWDCLK: J8.P$4, U3.51 (SWDCLK)
SWDIO: J8.P$3, U3.50 (SWDIO)
VDD_NRF: C1.1, C2.1, C10.1, FB1.1, U3.27 (VDD_NRF_27), U3.28 (VDD_NRF_28)
VDD_RADIO: C3.1, C4.1, C12.1, FB2.1, U3.21 (VDD_LR_21), U3.22 (VDD_LR_22)

Notes on the sheet:
系统3.3V电源
UART Interface
MCU NRF52840
USB type-c座子
电池及控制电路
LED
HM3416H更换为RY3420
BAT
FLASH
BLE_ANT
RESET
USER
WIFI_ANT
GPS_ANT
LORA_ANT
CHARG
POWER

Board: 2 copper layers, 55.5 x 74.1 mm, 96 parts (0 on the bottom side), 81 nets.

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
